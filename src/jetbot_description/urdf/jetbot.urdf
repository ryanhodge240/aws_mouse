Commit message: Add files via upload

File: src/jetbot_description/urdf/jetbot.urdf (robot description, URDF)
Before this commit: robot JetBot, 7 links, 6 joints
Joints:
- joint camera_joint: origin xyz=0.065   0      0.0857 rpy=0    0.25  0 -> xyz=$(arg camera_xyz) rpy=$(arg camera_rpy)
